options:
  parameters:
    author: corey
    generate_options: qt_gui
    id: lrs_example
    output_language: python
    title: LRS Pager Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '6.26'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '3190'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(samp_rate/2)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    int_max: '0'
    int_min: '-100'
    type: complex
  states: {}
- name: rfhs_lrs_source_0
  id: rfhs_lrs_source
  parameters:
    function: '1'
    pagerid: '10'
    printkey: 'True'
    randomkey: 'False'
    systemid: '123'
    verbose: 'False'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_throttle2_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rfhs_lrs_source_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
