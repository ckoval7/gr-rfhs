options:
  parameters:
    author: Corey Koval
    generate_options: qt_gui
    id: ask_example
    output_language: python
    title: ASK Example
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate/baud_rate)
    max_iter: '4000'
    scale: 0.9/20
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: baud_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: baud_rate/10
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: samp_rate
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    int_max: '0'
    int_min: '-100'
    type: float
  states: {}
- name: rfhs_ask_source_0
  id: rfhs_ask_source
  parameters:
    baud_rate: baud_rate
    repeat: '10'
    samp_rate: samp_rate
    text: A really long string so you can see stuff show up in the time sink.
  states: {}

connections:
- [blocks_moving_average_xx_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', blocks_moving_average_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rfhs_ask_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
